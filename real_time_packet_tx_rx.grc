options:
  parameters:
    author: Vivek
    generate_options: qt_gui
    id: top
    output_language: python
    title: Real Time Packet Transmission and Reception
  states: {}

blocks:
- name: filter_size
  id: variable
  parameters:
    value: '32'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_1
    step_size: '.0001'
    type: lms
  states: {}
- name: variable_constellation_1
  id: variable_constellation
  parameters:
    const_points: '[1, -1]'
    precision: '8'
    sym_map: '[0,1]'
    type: bpsk
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/2
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/vivek/Downloads/out3.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/vivek/Downloads/test.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Tagged Stream to PDU block up ahead needs packed bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: Append header to payload
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: digital_constellation_decoder_cb_1_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_1
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_1
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_correlate_access_code_xx_ts_1
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: Correlates with access code to extract the payload.
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_2_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    use_snr: 'True'
    w: '0.0628'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    sps: '4'
    taps: firdes.root_raised_cosine(filter_size, filter_size, 1.0/float(sps), 0.35, 11*sps*filter_size)
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    comment: Generate header
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: '1000'
    freq0: 500e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: '256000'
    sync: none
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '1000'
    center_freq0: 500e06
    clock_rate: '0.0'
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: '40'
    len_tag_name: ''
    samp_rate: '256000'
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_linear_equalizer_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_1, '0']
- [digital_constellation_decoder_cb_1_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_1, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_costas_loop_cc_2_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_linear_equalizer_0, '0', digital_constellation_decoder_cb_1_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_2_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [osmosdr_source_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [osmosdr_source_0_0, '0', qtgui_const_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
